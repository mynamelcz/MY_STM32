# Keil uVision project STM32F429.uvprojx, settings and files
target STM32F429 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32F429xx
  c include: ..\..\..\STM32F429_BSP\STM32_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\STM32F429_BSP\STM32_HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\STM32F429_BSP\STM32_HAL\CMSIS\Include;..\..\..\STM32F429_BSP\Lib\common\inc;..\..\..\STM32F429_BSP\Lib\CALC;..\..\..\STM32F429_BSP\Drv;..\..\..\STM32F429_BSP\Bsp\inc;..\bsp_cfg;..\Main\inc;..\DEV\key;..\DEV\TFTLCD;..\Driver\ST7789;..\DEV\SDRAM;..\Driver\IIC;..\DEV\EEPROM;..\Component\LVGL;..\Component\LVGL\src;..\Component\LVGL\examples\porting;..\LVGL_APP\demos;..\LVGL_APP\demos\stress;..\LVGL_APP\demos\music;..\Component\FreeRTOS\include;..\Component\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Main/: main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f429xx.s
  group Configure
    ../Main/inc/: board.h debug.h stm32f4xx_hal_conf.h FreeRTOSConfig.h
    ../bsp_cfg/: PER_PIN_MAP.h bsp_timer_cfg.h bsp_uart_cfg.h
  group Bsp
    ../../../STM32F429_BSP/Bsp/src/: bsp_gpio.c bsp_uart.c bsp_timer.c bsp_sys.c bsp_nvic.c bsp_fmc.c bsp_ltdc.c
  group Drv
    ../../../STM32F429_BSP/Drv/: time_delay.c
    ../Driver/ST7789/: st7789_drv.c
    ../Driver/IIC/: soft_iic_drv.c
  group Dev
    ../DEV/key/: key.c
    ../DEV/SDRAM/: sdram.c
    ../DEV/TFTLCD/: mcu_lcd.c rgb_lcd.c touch_capacitive.c touch_resistive.c
    ../DEV/EEPROM/: eeprom.c
  group Lib
    ../../../STM32F429_BSP/Lib/common/src/: cbuf.c common.c key_dec.c
  group STM32F4xx_HAL_Driver
    ../../../STM32F429_BSP/STM32_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group lvgl_port
    ../Component/LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl-core
    ../Component/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl-draw
    ../Component/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Component/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Component/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Component/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Component/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Component/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Component/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl-extra
    ../Component/LVGL/src/extra/: lv_extra.c
    ../Component/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Component/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Component/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../Component/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Component/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../Component/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Component/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Component/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../Component/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Component/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../Component/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Component/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Component/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Component/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../Component/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../Component/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Component/LVGL/src/extra/others/msg/: lv_msg.c
    ../Component/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Component/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Component/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Component/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Component/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Component/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Component/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Component/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Component/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Component/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Component/LVGL/src/extra/widgets/led/: lv_led.c
    ../Component/LVGL/src/extra/widgets/list/: lv_list.c
    ../Component/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Component/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Component/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Component/LVGL/src/extra/widgets/span/: lv_span.c
    ../Component/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Component/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Component/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Component/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Component/LVGL/src/extra/widgets/win/: lv_win.c
  group lvgl-font
    ../Component/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl-hal
    ../Component/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl-misc
    ../Component/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl-widgets
    ../Component/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group FreeRTOS-core
    ../Component/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS-port
    ../Component/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Component/FreeRTOS/portable/MemMang/: heap_4.c
